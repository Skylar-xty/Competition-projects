# Keil uVision project example.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: example +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER
  c include: ..\App\inc;..\Board\inc;..\CMSIS\CoreSupport;..\Libraries\inc;..\App\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../App/src/: main.c stm32f10x_it.c bsp_adc.c bsp_delay.c bsp_pwm.c bsp_servo.c bsp_usart.c bsp_usart_blt.c bsp_track.c bsp_control.c
    ../App/inc/: bsp_adc.h bsp_delay.h bsp_pwm.h bsp_servo.h bsp_usart.h bsp_usart_blt.h stm32f10x_conf.h stm32f10x_it.h bsp_track.h bsp_control.h
  group CMSIS
    ../CMSIS/: system_stm32f10x.c
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
